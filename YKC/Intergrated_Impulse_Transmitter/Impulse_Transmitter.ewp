# IAR project Impulse_Transmitter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: Include; Libraries; src_Transmitter; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Impulse_Transmitter.hex
  ILINK.IlinkOutputFile: Impulse_Transmitter.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    EWARM/: startup_stm32f10x_hd.s
  group Include
    Include/: misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_crc.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h system_stm32f10x.h
  group Libraries
    Libraries/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group src_Transmitter
    src_Transmitter/: bfifo.c bfifo.h bsb.c bsb.h checksum.c checksum.h main.c main.h mcu.h mcu_application.c mcu_application.h mcu_com.c mcu_com.h mcu_config.c mcu_config.h mcu_control_analog.c mcu_control_analog.h mcu_debug.c mcu_debug.h mcu_debug_shell.c mcu_equipment.c mcu_equipment.h mcu_gpio_alias.h mcu_istream.c mcu_istream.h mcu_nb_packet.c mcu_nb_packet.h mcu_peer.c mcu_peer.h mcu_redundant.c mcu_redundant.h message_queue.c message_queue.h stm32f10x_bit_define.h stm32f10x_conf.h stm32f10x_init.c stm32f10x_init.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c type.h
